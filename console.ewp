# IAR project console.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F051; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: lib\inc; user\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: console.hex
  ILINK.IlinkOutputFile: console.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group lib
    user/inc/: button.h cc85xx_dev.h cc85xx_ehif.h cc85xx_pair.h debug.h mcp2210_dev.h mcp2210_uaif.h stm32_led.h stm32_spi.h stm32_timer.h stm32f0xx_conf.h vocal_common.h vocal_led.h vocal_record.h vocal_sys.h
    lib/inc/: core_cm0.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_misc.h stm32f0xx_rcc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h
  group src
    user/src/: button.c cc85xx_dev.c cc85xx_ehif.c cc85xx_pair.c debug.c main.c mcp2210_dev.c mcp2210_uaif.c stm32_led.c stm32_spi.c stm32_timer.c stm32f0xx_it.c vocal_led.c vocal_record.c vocal_sys.c
    lib/src/: stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c system_stm32f0xx.c
