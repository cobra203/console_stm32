<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\CMSIS\core_cm0.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\core_cmFunc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\core_cmInstr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\startup\cstartup_M.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f0xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\startup\vector_table_M.s</name>
    </file>
  </group>
  <group>
    <name>FWlib</name>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\flash_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\src\stm32f0xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx_exti.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\src\stm32f0xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\src\stm32f0xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\src\stm32f0xx_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx_misc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\src\stm32f0xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx_rcc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\src\stm32f0xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\src\stm32f0xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx_syscfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\src\stm32f0xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\stm32f0xx_tim.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWlib\inc\system_stm32f0xx.h</name>
    </file>
  </group>
  <group>
    <name>USER</name>
    <file>
      <name>$PROJ_DIR$\USER\src\button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\button.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\cc85xx_dev.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\cc85xx_dev.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\cc85xx_ehif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\cc85xx_ehif.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\cc85xx_pair.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\cc85xx_pair.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\mcp2210_dev.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\mcp2210_dev.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\mcp2210_uaif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\mcp2210_uaif.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\stm32_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\stm32_led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\stm32_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\stm32_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\stm32_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\stm32_timer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\stm32f0xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\stm32f0xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\stm32f0xx_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\vocal_common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\vocal_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\vocal_led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\vocal_record.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\vocal_record.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\src\vocal_sys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\USER\inc\vocal_sys.h</name>
    </file>
  </group>
</project>


